options:
  parameters:
    generate_options: qt_gui
    id: nfm_rx_no_atan
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-70'
    step: '1'
    stop: '0'
    value: '-55'
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '.1'
    stop: '5'
    value: '1'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '75e-6'
    threshold: squelch
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/student/grc/nfm_rx_no_atan/nfm_rx_no_atan.wav
    samp_rate: '48000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, scale=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='HB FM Detect',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.scale = scale
              self.prev_last_i = 0
              self.prev_pent_i = 0
              self.prev_last_q = 0
              self.prev_pent_q = 0
              self.prev_last_theta = 0

          def work(self, input_items, output_items):
              i = input_items[0].real
              q = input_items[0].imag

              di = np.zeros(i.size)
              dq = np.zeros(q.size)

              dtheta = np.zeros(i.size)

              if i.size > 1:
                  di[0] = i[0] - self.prev_pent_i
                  di[1] = i[1] - self.prev_last_i
                  dq[0] = q[0] - self.prev_pent_q
                  dq[1] = q[1] - self.prev_last_q

                  di[2:] = i[2:] - i[:-2]
                  dq[2:] = q[2:] - q[:-2]

                  dtheta[0] = self.scale*(self.prev_last_i*dq[0] - self.prev_last_q*di[0])
                  dtheta[1:] = self.scale*(i[:-1]*dq[1:] - q[:-1]*di[1:])

                  self.prev_last_i = i[-1]
                  self.prev_pent_i = i[-2]
                  self.prev_last_q = q[-1]
                  self.prev_pent_q = q[-2]

              # theta = np.arctan2(q, i)
              # dtheta = np.zeros(theta.size)

              # dtheta[0] = theta[0] - self.prev_last_theta
              # dtheta[1:] = theta[1:] - theta[:-1]

              # dtheta[dtheta >= np.pi] -= 2*np.pi
              # dtheta[dtheta <= -np.pi] += 2*np.pi


              output_items[0][:] = dtheta

              #self.prev_last_theta = theta[-1]

              return len(output_items[0])
    scale: '1'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 25e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2.5e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '10'
    freq0: 423e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: samp_rate*10
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', epy_block_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [epy_block_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_1, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_1, '0', blocks_wavfile_sink_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
