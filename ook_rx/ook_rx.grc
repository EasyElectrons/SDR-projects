options:
  parameters:
    author: student
    generate_options: qt_gui
    id: ook_rx
    output_language: python
    title: ook_rx
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: bpf_symclk_rec
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: baud+50
    low_cutoff_freq: baud-50
    samp_rate: samp_rate
    type: band_pass
    width: baud/10
    win: firdes.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sps*baud
  states: {}
- name: sps
  id: variable
  parameters:
    value: '25'
  states: {}
- name: sym_delay
  id: variable_qtgui_range
  parameters:
    label: Symbol Delay
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '7'
    value: '0'
  states: {}
- name: upsamp
  id: variable
  parameters:
    value: '50'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sym_delay
    type: byte
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: (len(bpf_symclk_rec)-1)//2 % sps + sps//8
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/1
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/student/grc/ook_rx/test_out.dec.8u.real
    type: byte
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.decim_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, sps=25, symbol_threshold=.5):  # only default arguments here
              gr.decim_block.__init__(
                  self,
                  name='Clocked Unipolar NRZ Decoder',   # will show up in GRC
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.int8],
                  decim=sps
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.sps = sps
              self.sym_thresh = symbol_threshold

          def work(self, input_items, output_items):
              io = 0

              for n in range(1, input_items[0].size):
                  if input_items[1][n-1] < -.01 and .01 < input_items[1][n]: #rising edge
                      if io >= output_items[0].size:
                          output_items[0][:-1] = output_items[0][1:] # shift the first off the edge
                          io -= 1

                      output_items[0][io] = int(input_items[0][n] > self.sym_thresh)
                      io += 1

              return io
    sps: sps
    symbol_threshold: '.75'
  states: {}
- name: epy_block_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, scale=1.0, null_zone=.01):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Hard Limiter',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.scale = scale
              self.null_zone = null_zone

          def work(self, input_items, output_items):
              output_items[0][:] = np.array(input_items[0] > self.null_zone, dtype=int) - np.array(-self.null_zone > input_items[0], dtype=int)
              return len(output_items[0])
    null_zone: '0'
    scale: '1'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: bpf_symclk_rec
    type: fff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: baud
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: baud/10
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: 423e6
    fftsize: '1024'
    grid: 'True'
    legend: 'False'
    name: RX Spectrum
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: Envelope Det.
    label2: Symbol Clock Rec.
    name: Received Data
    nconnections: '2'
    size: 16*sps
    srate: samp_rate
    type: float
    ymax: '3'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: upsamp
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 423e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate*upsamp
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: preD
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: preD
  states: {}

connections:
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_0, '0', blocks_file_sink_1, '0']
- [blocks_delay_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_delay_1, '0', epy_block_0_0_0, '1']
- [blocks_delay_1, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [epy_block_0_0_0, '0', blocks_delay_0, '0']
- [epy_block_0_0_1, '0', blocks_delay_1, '0']
- [fir_filter_xxx_0, '0', epy_block_0_0_1, '0']
- [low_pass_filter_0, '0', epy_block_0_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_real_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
