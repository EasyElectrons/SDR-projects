options:
  parameters:
    author: student
    generate_options: qt_gui
    id: fm_bcast_stereo_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '88.1'
    step: '.2'
    stop: '108.1'
    value: '96.9'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: lpf_xla
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 15e3
    gain: '1.0'
    samp_rate: rf_rate/10
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: rf_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '25'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: 200e3
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_fm_demod_cf_1
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: 200e3
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: 15e3
    min_freq: '1'
    w: '.0628'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol/100
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol/100
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/student/grc/fm_bcast_stereo_rx/left_out.wav
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/student/grc/fm_bcast_stereo_rx/right_out.wav
    samp_rate: '48000'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 38e3
    decim: '1'
    samp_rate: rf_rate/10
    taps: lpf_xla
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: rf_rate/10
    type: fir_filter_fff
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq*1e6
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: rf_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: mono demod
    label2: diff demod
    nconnections: '2'
    size: '1024'
    srate: 200e3
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: L
    label2: R
    nconnections: '2'
    size: '1024'
    srate: 200e3
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: 200e3
    type: float
    ymax: '2'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: rf_rate
    fc: freq*1e6
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_add_xx_0, '0']
- [analog_fm_demod_cf_0, '0', blocks_sub_xx_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_fm_demod_cf_1, '0', blocks_add_xx_0, '1']
- [analog_fm_demod_cf_1, '0', blocks_multiply_xx_0, '0']
- [analog_fm_demod_cf_1, '0', blocks_sub_xx_0, '1']
- [analog_fm_demod_cf_1, '0', qtgui_time_sink_x_0, '1']
- [analog_pll_freqdet_cf_0, '0', blocks_multiply_xx_0, '1']
- [analog_pll_freqdet_cf_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_wavfile_sink_0_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_sub_xx_0, '0', rational_resampler_xxx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_fm_demod_cf_1, '0']
- [low_pass_filter_0, '0', blocks_add_xx_0, '1']
- [low_pass_filter_0, '0', blocks_sub_xx_0, '1']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_1, '0', analog_fm_demod_cf_0, '0']
- [rational_resampler_xxx_1, '0', analog_pll_freqdet_cf_0, '0']
- [rational_resampler_xxx_1, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
