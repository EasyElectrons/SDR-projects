options:
  parameters:
    generate_options: qt_gui
    id: fm_bcast_stereo_diff_only
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: rf_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_fmdet_cf_0
  id: analog_fmdet_cf
  parameters:
    freq_high: '75000'
    freq_low: '0'
    samplerate: rf_rate/10
    scl: '.1'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 19.5e3
    low_cutoff_freq: 18.5e3
    samp_rate: rf_rate/10
    type: fir_filter_fff
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 38.5e3
    low_cutoff_freq: 37.5e3
    samp_rate: rf_rate/10
    type: fir_filter_fff
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 53e3
    low_cutoff_freq: 23e3
    samp_rate: rf_rate/10
    type: fir_filter_fff
    width: 4e3
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: rf_rate/10
    type: fir_filter_fff
    width: 4e3
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 96.9e6
    gain0: '50'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: rf_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: pilot
    label2: rec carr
    nconnections: '2'
    size: '1024'
    srate: rf_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: diff
    size: '1024'
    srate: rf_rate/10
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: rf_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0,1,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '48'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_fmdet_cf_0, '0', band_pass_filter_0, '0']
- [analog_fmdet_cf_0, '0', band_pass_filter_2, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [band_pass_filter_1, '0', blocks_multiply_xx_1, '1']
- [band_pass_filter_1, '0', qtgui_time_sink_x_0, '1']
- [band_pass_filter_2, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_const_vxx_0, '0', band_pass_filter_1, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_fmdet_cf_0, '0']
- [rational_resampler_xxx_1, '0', audio_sink_0, '0']

metadata:
  file_format: 1
