options:
  parameters:
    author: student
    generate_options: qt_gui
    id: fm_bcast_stereo_rx_conventional
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fm_det_scale
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tab@0 : 0,2,1,1'
    label: fm det scale
    min_len: '50'
    orient: Qt.Horizontal
    start: '0'
    step: '.1'
    stop: '2'
    value: '.1'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tab@0 : 0,0,1,1'
    min_len: '50'
    orient: Qt.Horizontal
    start: '88.1'
    step: '.2'
    stop: '108.1'
    value: '96.9'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tab@0 : 0,1,1,1'
    min_len: '20'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '30'
    widget: dial
  states: {}
- name: rf_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tab@0 : 0,3,1,1'
    min_len: '20'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '25'
    widget: dial
  states: {}
- name: analog_fmdet_cf_0
  id: analog_fmdet_cf
  parameters:
    freq_high: 75e3
    freq_low: '0'
    samplerate: rf_rate/10
    scl: fm_det_scale
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 19.5e3
    low_cutoff_freq: 18.5e3
    samp_rate: rf_rate/10
    type: fir_filter_fff
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 38.5e3
    low_cutoff_freq: 37.5e3
    samp_rate: rf_rate/10
    type: fir_filter_fff
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 53e3
    low_cutoff_freq: 23e3
    samp_rate: rf_rate/10
    type: fir_filter_fff
    width: 4e3
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol/100
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol/100
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '50'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/student/grc/fm_bcast_stereo_rx/left_out.wav
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/student/grc/fm_bcast_stereo_rx/right_out.wav
    samp_rate: '48000'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: rf_rate/10
    type: fir_filter_fff
    width: 4e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: rf_rate/10
    type: fir_filter_fff
    width: 4e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@3
    label1: pilot
    label2: carr rec
    nconnections: '2'
    size: '128'
    srate: rf_rate/10
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@1
    label1: L
    label2: R
    nconnections: '2'
    size: '1024'
    srate: 200e3
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@2
    label1: mono
    label2: diff
    nconnections: '2'
    size: '1024'
    srate: rf_rate/10
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: rf_rate
    fc: freq*1e6
    fftsize: '1024'
    gui_hint: 'tab@0: 1,0,4,4'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq*1e6
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: rf_rate
    sync: sync
    type: fc32
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: contols
    label1: audio
    label2: demod
    label3: carr rec
    num_tabs: '4'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mono
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: diff
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: diff
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: mono
  states: {}

connections:
- [analog_fmdet_cf_0, '0', band_pass_filter_0, '0']
- [analog_fmdet_cf_0, '0', band_pass_filter_2, '0']
- [analog_fmdet_cf_0, '0', low_pass_filter_1, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [band_pass_filter_1, '0', blocks_multiply_xx_1, '1']
- [band_pass_filter_1, '0', qtgui_time_sink_x_0, '1']
- [band_pass_filter_2, '0', blocks_multiply_xx_1, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_wavfile_sink_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', band_pass_filter_1, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_sub_xx_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '1']
- [low_pass_filter_0, '0', virtual_sink_0_0, '0']
- [low_pass_filter_1, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_1, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_1, '0', analog_fmdet_cf_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_1, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '1']
- [virtual_source_0, '0', blocks_sub_xx_0, '1']
- [virtual_source_1, '0', blocks_add_xx_0, '0']
- [virtual_source_1, '0', blocks_sub_xx_0, '0']

metadata:
  file_format: 1
